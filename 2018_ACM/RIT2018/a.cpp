b.cpp0000600004115200411520000000060013371626450011036 0ustar  brownbrown#include "stdio.h"

int t;
int rx, ry, h;
int wx, wy, wl;
int n;
int ax[10005], ay[10005], bx[10005], by[10005];

int main(){
	scanf("%d", &t);
	for(int k = 0; k < t; k++){
		// getting inputs
		scanf("%d%d%d", &rx, &ry, &h);
		scanf("%d%d%d", &wx, &wy, &wl);
		scanf("%d",&n);
		for(int i = 0; i < n; i++){
			scanf("%d%d%d%d", &ax[i], &ay[i], &bx[i], &by[i]);
		}
		
		// bfs
	}

}
c.cpp0000600004115200411520000000151613371610250011035 0ustar  brownbrown#include<bits/stdc++.h>
using namespace std;

int t, n;
// c, (dx,dy)
set<pair<int, pair<int, int> > > s;
int px[2005], py[2005];


int main(){
	scanf("%d", &t);
	for(int k = 0; k < t; k++){
		s.clear();
		
		scanf("%d",&n);
		for(int i = 0; i < n; i++){
			scanf("%d %d", &px[i], &py[i]);
		}
		for(int i = 0; i < n; i++){
			for(int j = i + 1; j < n; j++){
				int dx, dy, c;
				dx = px[j]-px[i];
				dy = py[j]-py[i];
				
				int gc = __gcd(dx, dy);
				
				if(gc!=0){
					dx /= gc;
					dy /= gc;
				}
				
				if(dx < 0) {
					dx = -dx;
					dy = -dy;
				}
				
				if(dx == 0 && dy < 0) {
					dy = -dy;
				}
				
				if(!dx&&!dy){
					continue;		
				}
				
				c = dx*py[i] - dy*px[i];
				
				s.insert({c, {dx, dy}});
				//printf("Insert %d %d : %d %d %d\n", i,j,c,dx,dy);
			}
		}
		printf("%d\n", s.size());
	}
	return 0;
}
d.cpp0000600004115200411520000000221313371624326011042 0ustar  brownbrown#include <bits/stdc++.h>

int n,k,t;
long long int lcm[10005];
std::vector<int> deg[10005];
int ed1[1000005], ed2[1000005], dis[1000005];
bool sayNo;

int main(){
	scanf("%d", &t);
	for(int a = 0; a < t; a++){
				
		scanf("%d%d",&n,&k);
		
		// clear vector
		for(int i = 0; i <= n; i++){
			deg[i].clear();
		}
		sayNo = false;

		for(int i = 0; i < k; i++){
			scanf("%d%d%d", &ed1[i], &ed2[i], &dis[i]);
			deg[ed1[i]].push_back(dis[i]);
			deg[ed2[i]].push_back(dis[i]);
		}

		// loop though each
		for(int i = 1; i <= n && !sayNo; i++){
 			// cal lcm
			if(deg[i].empty()){
				// skip
				lcm[i] = 1;
				continue;
			}else if (deg[i].size() == 1){
				lcm[i] = deg[i][0];
			}else{
				lcm[i] = 1;
				for(int j = 0; j < deg[i].size(); j++){
					lcm[i] = (lcm[i]*deg[i][j])/std::__gcd((int)lcm[i],deg[i][j]);
					if(lcm[i] > 1000000){
						sayNo = true;
					}
				}
			}
			
			if(lcm[i] > 1000000){
				sayNo = true;
			}
		}

		// check the result
		for(int i = 0; i < k && !sayNo; i++){
			if(std::__gcd(lcm[ed1[i]], lcm[ed2[i]]) != dis[i]){
				sayNo = true;
			}				
		}

		if(sayNo){
			printf("NO\n");
		}else{
			printf("YES\n");
		}
	}

}

e.cpp0000600004115200411520000000351213371636733011053 0ustar  brownbrown#include<bits/stdc++.h>
using namespace std;
typedef pair<int,int> ii;
#define fi first
#define se second

int dx[] = {1, -1, 0, 0}, dy[] = {0, 0, 1, -1};
int n, lim, arr[505][505], cc[505][505];
pair<int,int> par[505][505], mx[505][505];
vector<pair<int, pair<int, int> > > srt ; 

bool inside(int x, int y){
	return (x >= 0) && (x < n) && (y >= 0) && (y < n) ;
}

ii rt(ii a){
	if(par[a.fi][a.se] == a) return a ;
	return par[a.fi][a.se] = rt(par[a.fi][a.se]); 
}

void unions(ii a, ii b) {
	if(rt(a) == rt(b)) return;
	ii aa = rt(a), bb = rt(b);
	par[aa.fi][aa.se] = bb;
	if(mx[aa.fi][aa.se].fi > mx[bb.fi][bb.se].fi) mx[bb.fi][bb.se] = mx[aa.fi][aa.se];
	else if(mx[aa.fi][aa.se].fi == mx[bb.fi][bb.se].fi) mx[bb.fi][bb.se].se++ ;
}

int main(){
	int t ; 
	scanf("%d", &t) ;
	while(t--){
		srt.clear(); 
		scanf("%d%d", &n, &lim);
		for(int i = 0 ; i < n ; i++){
			for(int j = 0 ; j < n ; j++){
				scanf("%d", arr[i] + j) ;
				srt.push_back({arr[i][j], {i, j}});
				par[i][j] = ii(i,j);
				mx[i][j] = ii(arr[i][j], 1) ;
			}
		}
		
		sort(srt.begin(), srt.end());
		reverse(srt.begin(), srt.end());
		int ptr = 0 ;
		int ans = 0 ;
		for(int i = 0; i < srt.size() ; i++){
			int xx = srt[i].se.fi, yy = srt[i].se.se ;
			int val = srt[i].fi ;
			int thres = val - lim ;
			cout << val << " " << thres << " " << xx << " " << yy << endl;
			while((ptr < srt.size()) && (srt[ptr].fi > thres)){
				int cx = srt[ptr].se.fi, cy = srt[ptr].se.se ;
				for(int j = 0; j < 4; j++){
					int nx = cx + dx[j], ny = cy + dy[j];
					if(!inside(nx,ny)) continue ;
					if(arr[nx][ny] > thres) {
						unions(ii(cx,cy), ii(nx,ny));
					}
				}
				cout << cx << " " << cy << ":" << srt[ptr].fi << endl;
				ptr++;
			}
			ii rtt = rt(ii(xx,yy));
			if((mx[rtt.fi][rtt.se].fi == val) && (mx[rtt.fi][rtt.se].se == 1)){
				ans++;
			}
		}
		printf("%d\n", ans) ; 
	}
}



e2.cpp0000600004115200411520000000447213371625402011132 0ustar  brownbrown#include<bits/stdc++.h>
using namespace std;
typedef pair<int,int> ii;
#define fi first
#define se second

int dx[] = {1, -1, 0, 0}, dy[] = {0, 0, 1, -1};
int n, lim, arr[505][505], cc[505][505], cnt = 1;
int vv[250050];
pair<int,int> mx[250050];
int par[250050] ;
vector<ii> srt ; 
vector<ii> sc[250050] ;

bool inside(int x, int y){
	return (x >= 0) && (x < n) && (y >= 0) && (y < n) ;
}

int rt(int a){
	if(par[a] == a) return a ;
	return par[a] = rt(par[a]); 
}

void unions(int a, int b) {
	if(rt(a) == rt(b)) return;
	int aa = rt(a), bb = rt(b);
	par[aa] = bb;
	if(mx[aa].fi > mx[bb].fi) mx[bb] = mx[aa];
	else if(mx[aa].fi == mx[bb].fi) mx[bb].se++ ;
}

void dfs(int x, int y){
	cc[x][y] = cnt ;
	sc[cnt].push_back(ii(x,y)) ; 
	for(int i=0 ;i< 4; i++){
		int  nx = x +dx[i] , ny = y + dy[i] ; 
		if(!inside(nx, ny) || cc[nx][ny] != 0) continue;
		if(arr[nx][ny] == arr[x][y]) dfs(nx, ny) ; 
	}
}

int main(){
	int t ; 
	scanf("%d", &t) ;
	while(t--){
		srt.clear(); 
		scanf("%d%d", &n, &lim);
		for(int i = 0 ; i < n ; i++){
			for(int j = 0 ; j < n ; j++){
				scanf("%d", arr[i] + j) ;
			}
		}
		for(int i = 0; i < 250010 ;i++){
			par[i] = i; 
			mx[i] = {0,0} ; 
			sc[i].clear();	
			vv[i] = 0 ;	
		}
		cnt = 1; 
		memset(cc, 0 ,sizeof cc) ;
		srt.clear();
		for(int i = 0 ; i < n ; i++){
			for(int j = 0 ; j < n ; j++){
				if(cc[i][j]) continue ;
				dfs(i,j) ;
				mx[cnt] = ii(arr[i][j], 1) ;
				vv[cnt] = arr[i][j] ; 
				cnt++ ;
			}
		}
		for(int i = 1; i < cnt; i++) par[i] = i, srt.push_back(ii(mx[i].fi, i));
		sort(srt.begin(), srt.end());
		reverse(srt.begin(), srt.end());
		int ptr = 0 ;
		int ans = 0 ;
		for(int i = 0; i < srt.size(); i++){
			int cur = srt[i].se, val = srt[i].fi;
			int thres = val - lim ; 
			//printf("%d %d %d:\n",cur,val,thres) ; 
			while((ptr < srt.size()) && (srt[ptr].fi > thres)){
				int curr = srt[ptr].se ;
				//printf("- %d %d\n",curr,srt[ptr].fi) ; 
				for(ii v : sc[curr]){
					int cx = v.fi, cy = v.se ; 
					for(int j = 0; j < 4; j++){
						int nx = cx + dx[j], ny = cy + dy[j];
						if(!inside(nx,ny)) continue ;
						if(arr[nx][ny] > thres) {
							unions(cc[nx][ny], curr);
						}
					}
				}
				ptr++;
			}
			int rc = rt(cur) ;
			//cout << mx[rc].fi << " " << mx[rc].se << endl ; 
			if((mx[rc].fi == vv[cur]) && (mx[rc].se == 1)) ans++ ; 
		}
		printf("%d\n", ans) ; 
	}
}



f.cpp0000600004115200411520000000104613371606266011052 0ustar  brownbrown#include<bits/stdc++.h>
using namespace std;

int srt[5][1000010], n;

int main(){
	int t;
	scanf("%d", &t);
	while(t--){
		memset(srt, 0, sizeof srt);
		scanf("%d",&n) ;
		for(int i=0;i<n;i++){
			int x, y ;
			scanf("%d%d",&x,&y) ;
			srt[0][i] = x;
			srt[1][i] = y;
			srt[2][i] = x+y;
			srt[3][i] = x-y;			
		}
		bool ok = 1 ;
		for(int i = 0; i< 4 ; i++) {
			sort(srt[i], srt[i] + n) ;
			for(int j = 0; j < (n - 1); j++){
				ok = ok & !(srt[i][j] == srt[i][j+1]);
			}
		}
		if(ok) printf("YES\n");
		else printf("NO\n");
	}
	return 0; 
}

i.cpp0000600004115200411520000000065213371636733011061 0ustar  brownbrown#include <bits/stdc++.h>
//#include <climits.h>

typedef unsigned long long ll;
using namespace std;	

ll t;
vector<pair<pair<ll, ll>, pair<ll, ll> > >v;
ll n;

pair<ll, ll> dp[ending_time][2];

ll f(ll tx, ll ty, 

int main()
{
	while(t--) {
		v.clear();
		cin >> n;
		for(int i = 0; i < n; i++) {
			ll a, b, c, d;
			cin >> a >> b >> c >> d;
			v.push_back({{b, a}, {c, d}});
		}	
		
		sort(v.begin(), v.end())
	}
	
	dp[
}
t.cpp0000600004115200411520000000023113371607111011051 0ustar  brownbrown#include <bits/stdc++.h>
using namespace std;

int main() {
	cout << __gcd(-3, 5);
	cout << endl;
	cout << __gcd(0, 5) << " " <<  __gcd(5, 0) << endl;
}
